# Keil uVision project RoboMasterDevelopmentBoardC.uvprojx, settings and files
target RoboMasterDevelopmentBoardC (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: STM32F407IGHx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.14.0
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x80FFFFF)  CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4") TZ
  output: RoboMasterDevelopmentBoardC +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=3
  c define: USE_HAL_DRIVER,STM32F407xx
  c misc: --cpp11
  c include: ../Core/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32F4xx/Include;../Drivers/CMSIS/Include;../Middlewares/Third_Party/FreeRTOS/Source/include;../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS;../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F;..\SRML\Drivers\Components;..\SRML\Drivers\Devices;..\SRML;..\USP\Trunk;..\USP\Protocol;..\USP\System;..\USP\UpperMonitor;..\USP;..\USP\Protocol;..\SRML\Middlewares\Module
  asm include: ..\Core\Inc
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Application/User/System
    ../USP/System/: System_Tasks.cpp System_Config.cpp System_Datapool.cpp System_Datapool.h
  group Application/User/Core
    ../Core/Src/: main.c freertos.c stm32f4xx_it.c stm32f4xx_hal_msp.c stm32f4xx_hal_timebase_tim.c
  group Application/MDK-ARM
    ./: startup_stm32f407xx.s
  group Middlewares/Trunk
    ../USP/Trunk/: Service_Communication.cpp Service_Trunk.cpp Service_Chassis.cpp Service_LED.cpp Service_PWM.cpp
  group Middlewares/Algorithm
    ../SRML/Middlewares/Algorithm/: PID.cpp filters.cpp
  group Middlewares/UpperMonitor
    ../USP/UpperMonitor/: UpperMonitor.cpp
  group Middlewares/FreeRTOS
    ../Middlewares/Third_Party/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS/: cmsis_os.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F/: port.c
  group Drivers/Devices
    ../SRML/Drivers/Devices/: dr16.cpp Motor.h
    ../../../../STM32_BladeWall/STM32F407IGH_BladeWall/SCUTRobotLab_BladeWall/SRML/Middlewares/Module/: chassis.cpp
    ../USP/Protocol/: stm32flash.cpp
    ../USP/: srml_config.h
  group Drivers/Components
    ../SRML/Drivers/Components/: drv_can.c drv_flash.c drv_uart.c drv_timer.c
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_can.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal.c stm32f4xx_hal_exti.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_uart.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f4xx.c
software components: CMSIS:CORE 4.3.0
